# Keil uVision project Dev_IS.uvprojx, settings and files
target Simu (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Dev_IS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Pilotes\include;.\Service
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ./: Principal.c
  group Services
    ./Service/: API_COM_TP_4IS.c
  group Pilotes
    ./Pilotes/: clock.c Drivers_STM32F103_107_Juin2017a.lib USART_rev.c Xbee_usart.c Xbee_cmd.c fm_usart.c fm_cmd.c
  group Tests
    ./Tests/: tests_xbee.c test_fm.c
  group Documentation
    ./: Dev_IS.doxy
target Reel (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: Dev_IS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEBUG__
  c include: .\Pilotes\include;.\Service;.\Tests
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target TU (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: Dev_IS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __TESTS__ __DEBUG__
  c include: .\Pilotes\include;.\Service;.\Tests;.\RTE\Device\STM32F103RB;C:\Keil\ARM\Pack\ARM\CMSIS\4.5.0\CMSIS\Include;C:\Keil\ARM\Pack\Keil\STM32F1xx_DFP\2.0.0\Device\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target Tests_Hard (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: Dev_IS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __TESTS__ __DEBUG__
  c include: .\Pilotes\include;.\Service;.\Tests
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
