# Keil uVision project Reseau_Capteurs.uvproj, settings and files
target Simu (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Reseau_Capteurs
  c flags: Optim=1 OneElfS=1
  c define: _LCD_DEBUG_ STM32F10X_MD
  c include: .;C:\Keil\stm32lib\stm32f10x\peripherals\inc;.\drivers;.\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    C:/Keil/stm32lib/stm32f10x/boot/stm32f103/: startup-rvds.s
  group App
    ./: main.c Retarget.c debugsetup.ini
  group Lib
    C:/Keil/stm32lib/stm32f10x/peripherals/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group Drivers - src
    ./drivers/: configuration.c uart.c LCD_4bit.c clock.c miscellaneous.c
target Reel (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Reseau_Capteurs
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target Drivers (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Reseau_Capteurs
  c flags: Optim=1
  c include: ..\V6;.\drivers;.\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
